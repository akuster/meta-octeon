
do_configure_append() {
     sed -i Makefile -e "s,-mips3,,"
}
